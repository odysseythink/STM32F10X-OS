# Keil uVision project STM32F10X-OS.uvprojx, settings and files
target STM32F10X-OS (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F10X-OS +hex
  AfterMake: fromelf.exe --bin -o ./STM32F10X-OS.bin  ./Objects/STM32F10X-OS.axf
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\Source\User;..\Source\OS;..\Source\ST_Libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group ST_Libraries\Startup
    ../Source/ST_Libraries/Startup/: startup_stm32f10x_md.s
  group ST_Libraries\CMSIS
    ../Source/ST_Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group ST_Libraries\STM32F10x_StdPeriph_Driver
    ../Source/ST_Libraries/STM32F10x_StdPeriph_Driver/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_dma.c
  group ST_Libraries
    ../Source/ST_Libraries/: stm32f10x_it.c
  group OS
    ../Source/OS/: OS.c
  group User
    ../Source/User/: main.c
  group User\serial_debug
    ../Source/User/serial_debug/: serial_debug.c
  group USer\Communication
    ../Source/User/Communication/: Commu.c Commu_Uart.c Task_Commu.c
  group User\Mem
    ../Source/User/Mem/: Mem.c
  group User\List
    ../Source/User/List/: List.c
